require lk.inc

LK_BRANCH = "release/LA.BR.1.2.7-03810-8x16.0+rescue"
LK_REVISION = "7647debfbe543a652f056d075b0fcaeb47cbde3b"
LK_MACHINE = "dragonboard-410c"
LK_FLAVOUR = "-sd-rescue"

