RDEPENDS_${PN} += "binutils-cross-canadian-arm-none-eabi gcc-cross-canadian-arm-none-eabi"
