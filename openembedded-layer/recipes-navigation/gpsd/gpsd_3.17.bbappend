FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
    file://0001-Introduce-Qualcomm-PDS-service-support.patch \
"
