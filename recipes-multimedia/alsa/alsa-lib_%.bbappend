FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dragonboard-410c = "file://0001-ucm-Add-ucm-files-for-DB410c-board.patch"
