RDEPENDS_${PN}_append_dragonboard-845c = " networkmanager-qcom"
