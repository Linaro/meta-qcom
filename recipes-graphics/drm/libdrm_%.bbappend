FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://freedreno_ksgl.patch"
