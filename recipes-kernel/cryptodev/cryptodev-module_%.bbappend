FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI:append:qcom = " file://0001-Fix-build-for-Linux-5.11-rc1.patch"
