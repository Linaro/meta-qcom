# Copyright (C) 2021 Linaro
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-kernel/linux/linux-linaro-qcom.inc

SRCREV = "4301c7b4d507687fc2301edb4fcea76188e39396"
