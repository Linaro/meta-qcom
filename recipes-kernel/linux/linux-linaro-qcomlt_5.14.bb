# Copyright (C) 2014-2020 Linaro
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-kernel/linux/linux-linaro-qcom.inc

SRCBRANCH = "release/sa8155p-adp/qcomlt-5.14"
SRCREV = "9f2bf2add46548ce1c77cd66cd3e828523fe96e8"

COMPATIBLE_MACHINE = "(sa8155p)"
