require recipes-kernel/linux/linux-linaro-qcom.inc

COMPATIBLE_MACHINE = "(sa8155p)"
SRCBRANCH = "sa8155p-adp/qcomlt-track-upstream"
SRCREV = "ecd82903edb65c18195c83e697cfcfd0815cf02a"
