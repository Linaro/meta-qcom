# Copyright (C) 2021 Linaro
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-kernel/linux/linux-linaro-qcom.inc

SRCBRANCH = "release/qcomlt-6.0"
SRCREV = "759763eb59da99b2f2ff9089b5fcb955d508959c"
