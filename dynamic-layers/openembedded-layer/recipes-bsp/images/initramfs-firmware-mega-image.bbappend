# WoA devices
PACKAGE_INSTALL += " \
    packagegroup-firmware-ecs-liva-qc710 \
    packagegroup-firmware-lenovo-miix-630 \
    packagegroup-firmware-lenovo-yoga-c630 \
    packagegroup-firmware-lenovo-x13s \
    packagegroup-firmware-sc8180x \
    packagegroup-firmware-x1e80100-crd \
"
