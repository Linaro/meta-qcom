PACKAGE_INSTALL += " \
    firmware-qcom-nexus5x \
    firmware-qcom-nexus6p \
    firmware-qcom-pixel \
    firmware-qcom-pixel2 \
    firmware-qcom-pixel3 \
    firmware-qcom-pixel3a \
    firmware-qcom-pixel4 \
    firmware-qcom-pixel4a \
    firmware-qcom-pixel4a-5g \
    firmware-qcom-pixel5 \
    firmware-qcom-pixel5a-5g \
"
