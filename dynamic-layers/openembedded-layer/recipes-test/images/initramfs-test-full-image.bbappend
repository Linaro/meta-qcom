PACKAGE_INSTALL += " \
    crash \
    devmem2 \
    iozone3 \
    libgpiod \
    libgpiod-tools \
    makedumpfile \
"
