initramfs-test-image.bbappend