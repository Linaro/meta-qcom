PACKAGE_INSTALL += " \
    cryptsetup \
    devmem2 \
"
